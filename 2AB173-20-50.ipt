# Autodesk Inventor part: 2AB173-20-50
## iProperties
Created: 2007-10
Part Number: 2AB173-20-50
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
